# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Hardware;.\SYSTEM;.\User
  group SYSTEM
    ./SYSTEM/: delay.c delay.h sys.c sys.h timer.c timer.h
  group USER
    ./User/: config.h interrupt.c main.c
  group HARDWARE
    ./Hardware/: key.c key.h led.c led.h smg.c smg.h beep.c beep.h ir.c ir.h hc_sr04.c hc_sr04.h lcd1602.c lcd1602.h motor.c motor.h bt.c bt.h
