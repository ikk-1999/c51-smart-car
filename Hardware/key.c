#include "Hardware/key.h"
#include "SYSTEM/delay.h"
#include "User/config.h"

// ============================================================
// 独立按键驱动 — 非阻塞扫描 + 边沿检测
//
// 电路：
//   K1=P3.4, K2=P3.5, K3=P3.6, K4=P3.7
//   未按键：上拉电阻 → 高电平 (读到 1)
//   按下：  引脚接地 → 低电平 (读到 0)
//
// 核心机制：
//   1. KeyInfo_t 结构体数组管理 4 个键:
//      - mask: P3 位掩码，用 (P3 & mask) == 0 判断按下
//      - last_state: 前次扫描状态（0=松, 1=已触发）
//
//   2. 边沿检测（edge detection）:
//      只在 "当前按下 且 上次未触发" 时返回键值
//      → 每次按下只触发一次，按住不放不重复
//
//   3. 消抖（debounce）:
//      检测到低电平后 delay 20ms 再读一次
//      → 滤除机械抖动 (<10ms 的抖动被忽略)
//
// ⚠️ 阻塞警告：
//   消抖的 delay_ms(KEY_DEBOUNCE_MS) 会阻塞主循环 20ms。
//   这意味着按键按下时会丢失约 2 轮超声波采样。
//   如需完全无阻塞，可改为"时间戳比较"方式消抖。
// ============================================================

// --- 按键结构体 ---
typedef struct {
    u8 mask;         // P3 位掩码：K1=0x10(P3.4), K2=0x20(P3.5), ...
    u8 last_state;   // 0=上次扫描是松开的  1=已触发(防重复)
} KeyInfo_t;

// --- 4 键数组 (按 KEY_K1~KEY_K4 顺序, 与 KeyCode_t 枚举对应) ---
static KeyInfo_t key_info[4] = {
    {0x10, 0},   // K1: P3.4 → KEY_K1=1
    {0x20, 0},   // K2: P3.5 → KEY_K2=2
    {0x40, 0},   // K3: P3.6 → KEY_K3=3
    {0x80, 0},   // K4: P3.7 → KEY_K4=4
};

void Key_Init(void)
{
    // 准双向口：必须先写 1 才能读引脚电平
    // 如果不写 1，端口锁存器为 0 → 强下拉 → 读到的永远是 0
    K1_PIN = 1;
    K2_PIN = 1;
    K3_PIN = 1;
    K4_PIN = 1;
}

// ============================================================
// Key_Scan — 非阻塞按键扫描
//
// 返回：仅在"按下瞬间"返回对应 KeyCode_t，其余返回 KEY_NONE
//
// 时序图 (以 K1 为例, ↓为按下, ↑为松开):
//
//   物理按键:  ─────╲___________╱────
//                   机械抖动(≈5ms)
//
//   第1次扫描:      读=0,但last=0 → 进消抖 → 等20ms
//   第2次扫描:      20ms后,读=0 → 确认为按下 → 返回 KEY_K1
//   第3~N次扫描:    last=1 防重复 → 返回 KEY_NONE
//   (松手后):       读=1 → last=0 → 回到就绪
//
// 调用频率建议:
//   主循环 < 50ms 一轮即可, 当前约 10ms
//   如果主循环 > 100ms, 可能漏掉短暂按键
// ============================================================
KeyCode_t Key_Scan(void)
{
    u8 i;

    for (i = 0; i < 4; i++)
    {
        // 读该键对应引脚电平
        // (P3 & mask) == 0 → 按下 (低电平)
        if ((P3 & key_info[i].mask) == 0)
        {
            // 只有"上次是松开的"才尝试消抖
            if (key_info[i].last_state == 0)
            {
                delay_ms(KEY_DEBOUNCE_MS);   // 等 20ms 消抖

                // 消抖后再次确认
                if ((P3 & key_info[i].mask) == 0)
                {
                    // 确认为有效按下 → 标记已触发 → 返回键值
                    key_info[i].last_state = 1;
                    return (KeyCode_t)(i + 1);  // i=0→KEY_K1
                }
                // else: 是抖动 → 不标记, 等下次松手后重试
            }
            // else: last_state=1 → 已触发过了, 按住不重复
        }
        else
        {
            // 引脚高电平 → 按键已松开 → 复位, 等下次按下
            key_info[i].last_state = 0;
        }
    }

    return KEY_NONE;
}
